# IAR project LQ_K66FX_IIC9AX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\Includes; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\User; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\Project_Setting; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\Project_Setting\Startup; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\Project_Setting\Linker_Files; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\Libs; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\BasicMathFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\CommonTables; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\ComplexMathFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\ControllerFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\FastMathFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\FilteringFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\MatrixFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\StatisticsFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\SupportFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src\ARM_math\TransformFunctions; $TOOLKIT_DIR$\..\..\..\..\Software Resourses\K66FX核心板资料\三轮组\改5.28（另一个要加各种参数）\改5.28（另一个要加各种参数）\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_IIC9AX.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker_Files\K66_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: src\Includes; src\User; src\Project_Setting; src\Project_Setting\Startup; src\Project_Setting\Linker_Files; src\Libs; src\ARM_math\BasicMathFunctions; src\ARM_math\CommonTables; src\ARM_math\ComplexMathFunctions; src\ARM_math\ControllerFunctions; src\ARM_math\FastMathFunctions; src\ARM_math\FilteringFunctions; src\ARM_math\MatrixFunctions; src\ARM_math\StatisticsFunctions; src\ARM_math\SupportFunctions; src\ARM_math\TransformFunctions
  OBJCOPY.OOCOutputFile: LQ_K66FX_IIC9AX.hex
  group Driver/ADC
    src/Source/: ADC.c
    src/Includes/: ADC.h
  group Driver/DMA
    src/Source/: DMA.c
    src/Includes/: DMA.h
  group Driver/FTM
    src/Source/: FTM.c
    src/Includes/: FTM.h
  group Driver/GPIO
    src/Source/: GPIO.c
    src/Includes/: GPIO.h GPIO_Cfg.h
  group Driver/IIC
    src/Source/: I2C.c
    src/Includes/: I2C.h
  group Driver/LPTMR
    src/Source/: LPTMR.c
    src/Includes/: Lptmr.h
  group Driver/PIT
    src/Source/: PIT.c
    src/Includes/: PIT.h
  group Driver/PLL
    src/Source/: PLL.c
    src/Includes/: PLL.h
  group Driver/RTC
    src/Source/: RTC.c
    src/Includes/: RTC.h
  group Driver/Systick
    src/Source/: Systick.c
    src/Includes/: Systick.h
  group Driver/UART
    src/Source/: UART.c
    src/Includes/: UART.h
  group Driver/Vectors
    src/Source/: vectors.c
    src/Includes/: vectors.h
  group Driver/WDOG
    src/Source/: wdog.c
    src/Includes/: wdog.h
  group header
    src/Libs/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h MK66F18.h
  group Include
    src/Source/: common.c
    src/Includes/: common.h
    src/User/: include.h
  group Start up
    src/Project_Setting/Startup/: crt0.s start.c
  group User
    src/User/: main.c
  group User/ANO
    src/User/: ANO_DT.c ANO_DT.h
  group User/KEY
    src/Source/: KEY.c
    src/Includes/: KEY.h
  group User/LED
    src/Source/: LED.c
    src/Includes/: LED.h
  group User/LQ12864
    src/Source/: LQ12864.c
    src/Includes/: LQ12864.h
  group User/LQ_9AX
    src/User/: LQ9AX.h
  group User/LQ_I2C
    src/User/: u_iic.c u_iic.h
  group User/LQ_MPU6050
    src/User/: LQIIC6050.c LQMPU6050.h
  group User/LQ_MT9V034
    src/User/: LQMT9V034.c LQMT9V034.h
  group User/Mpu9050
    src/User/: MPU9250.c MPU9250.h
  group User/Serial_oscilloscope
    src/User/: Serial_oscilloscope.c Serial_oscilloscope.h
